# Keil uVision project project.uvprojx, settings and files
target rt-thread (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: rt-thread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER, __CLK_TCK=RT_TICK_PER_SECOND, RT_USING_ARM_LIBC, __RTTHREAD__, STM32F103xE
  c include: applications;..\..\..\libcpu\arm\common;..\..\..\libcpu\arm\cortex-m3;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\spi;..\..\..\components\drivers\include;..\..\..\components\drivers\spi\sfud\inc;..\..\..\components\drivers\include;board;board\CubeMX_Config\Inc;board\ports\include;..\libraries\HAL_Drivers;..\libraries\HAL_Drivers\config;..\..\..\components\dfs\include;..\..\..\components\dfs\filesystems\devfs;..\..\..\components\dfs\filesystems\elmfat;..\..\..\components\finsh;.;..\..\..\include;..\..\..\components\libc\compilers\armlibc;..\..\..\components\libc\compilers\common;..\..\..\components\libc\compilers\common\none-gcc;..\libraries\STM32F1xx_HAL\CMSIS\Device\ST\STM32F1xx\Include;..\libraries\STM32F1xx_HAL\STM32F1xx_HAL_Driver\Inc;..\libraries\STM32F1xx_HAL\CMSIS\Include;..\..\..\examples\utest\testcases\kernel
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/: temp.c dfs_test.c main.c
  group CPU
    ../../../libcpu/arm/common/: backtrace.c showmem.c div0.c
    ../../../libcpu/arm/cortex-m3/: context_rvds.S cpuport.c
  group DeviceDrivers
    ../../../components/drivers/misc/: pin.c
    ../../../components/drivers/sdio/: mmc.c sd.c block_dev.c sdio.c mmcsd_core.c
    ../../../components/drivers/serial/: serial.c
    ../../../components/drivers/spi/sfud/src/: sfud.c sfud_sfdp.c
    ../../../components/drivers/spi/: spi_flash_sfud.c spi_core.c spi_dev.c
    ../../../components/drivers/src/: dataqueue.c ringblk_buf.c pipe.c ringbuffer.c completion.c waitqueue.c workqueue.c
  group Drivers
    board/ports/: sdcard_port.c
    board/CubeMX_Config/Src/: stm32f1xx_hal_msp.c
    board/: board.c
    ../libraries/STM32F1xx_HAL/CMSIS/Device/ST/STM32F1xx/Source/Templates/arm/: startup_stm32f103xe.s
    ../libraries/HAL_Drivers/: drv_gpio.c drv_common.c drv_usart.c drv_sdio.c drv_spi.c
  group Filesystem
    ../../../components/dfs/src/: dfs_posix.c dfs_file.c select.c dfs.c poll.c dfs_fs.c
    ../../../components/dfs/filesystems/devfs/: devfs.c
    ../../../components/dfs/filesystems/elmfat/: ffunicode.c ff.c dfs_elm.c
  group finsh
    ../../../components/finsh/: shell.c msh_file.c cmd.c msh.c
  group Kernel
    ../../../src/: components.c irq.c device.c timer.c object.c scheduler.c mem.c thread.c clock.c idle.c ipc.c mempool.c kservice.c
  group libc
    ../../../components/libc/compilers/armlibc/: libc.c syscalls.c stdio.c mem_std.c
    ../../../components/libc/compilers/common/: time.c unistd.c delay.c stdlib.c
  group Libraries
    ../libraries/STM32F1xx_HAL/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_rcc_ex.c stm32f1xx_ll_spi.c stm32f1xx_hal_cortex.c stm32f1xx_hal_spi.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_rcc.c stm32f1xx_hal_pwr.c stm32f1xx_hal_dma.c stm32f1xx_hal_sd.c stm32f1xx_hal_crc.c stm32f1xx_hal_uart.c stm32f1xx_hal.c stm32f1xx_ll_sdmmc.c stm32f1xx_hal_cec.c stm32f1xx_hal_usart.c stm32f1xx_hal_gpio.c
    ../libraries/STM32F1xx_HAL/CMSIS/Device/ST/STM32F1xx/Source/Templates/: system_stm32f1xx.c
